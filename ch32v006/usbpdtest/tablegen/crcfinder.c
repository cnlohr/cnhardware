#include <stdint.h>
#include <stdio.h>

#define CRC_POLY 0x04C11DB7

//uint8_t example_packet[] = { 0xa6, 0x09, 0x34, 0xb1, 0x58, 0xc0,};
//uint8_t example_packet[] = { 0xa6, 0x0b, 0x18, 0xd0, 0x56, 0x2e, };


//uint8_t example_packet[] = { 0xa1, 0x75, 0x2c, 0x91, 0x01, 0x08, 0x2c, 0xd1, 0x02, 0x00, 0x2c, 0xc1, 0x03, 0x00, 0x2c, 0xb1, 0x04, 0x00, 0xf4, 0x41, 0x06, 0x00, 0x64, 0x21, 0xdc, 0xc0, 0x64, 0x21, 0x90, 0xc1, 0x23, 0xb3, 0xe7, 0x14, };

//uint8_t example_packet[] = { 0xa1, 0x73, 0x2c, 0x91, 0x01, 0x08, 0x2c, 0xd1, 0x02, 0x00, 0x2c, 0xc1, 0x03, 0x00, 0x2c, 0xb1, 0x04, 0x00, 0xf4, 0x41, 0x06, 0x00, 0x64, 0x21, 0xdc, 0xc0, 0x64, 0x21, 0x90, 0xc1, 0xba, 0x63, 0x86, 0x85, };

//0xea4afa09
/*
const char example_packet[] = {
     0xa1, 0x41,
     0x2c, 0x91, 0x01, 0x0a,
     0x2c, 0xd1, 0x02, 0x00,
     0x2c, 0xb1, 0x04, 0x00,
     0x45, 0x41, 0x06, 0x00,
	0x09, 0xfa, 0x4a, 0xea
 };
*/

int main()
{
	uint64_t checkzero = 0xffffffff;
//	for( checkzero = 0; checkzero < 0x100000000ULL; checkzero++ )
	{
		uint32_t current_crc = 0xffffffff;

		if( ( checkzero & 0xffffff) == 0 ) printf( "%08lx\n", checkzero );

		int i;
		for( i = 0; i < sizeof(example_packet); i++ )
		{
			uint8_t by = example_packet[i];
			uint32_t newbit, newword;
			uint32_t rl_crc;
			for(int i=0; i<8; i++) {
				newbit = ((current_crc>>31) ^ ((by>>i)&1)) & 1;
				if(newbit) newword=CRC_POLY; else newword=0;
				rl_crc = (current_crc<<1) | newbit;
				current_crc = rl_crc ^ newword;
			}
		}
		printf( "%08x\n", current_crc );

		if( current_crc == 0 )
		{
			printf( "Initial: %08lx\n", checkzero );
		}

		int crccheck = 0;
		uint32_t j, bit;
		current_crc = ~current_crc;
		for(int i=0;i<32;i++) {
		    j = 31-i;
		    bit = (current_crc>>i) & 1;
		    crccheck |= bit<<j;
		}
		printf( "%08x %08x\n", crccheck, current_crc );
	}
}
